# Keil uVision project CH547.uvproj, settings and files
target CH547 (MCS-51)
  device: CH549 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: CH547 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BSP;.\USER;.\OPT
  link misc: REMOVEUNUSED
  group USER
    ./USER/: Main.C
  group PUBLIC
    ./Public/: DEBUG.C
  group BSP
    ./BSP/GPIO/: GPIO.C
    ./BSP/Timer/: Timer.C
    ./BSP/TouchKey/: TouchKey.C
    ./BSP/PWM/: PWM.C
    ./BSP/UART/: UART.C
  group Opt
    ./OPT/: beep.c led.c serial.c
