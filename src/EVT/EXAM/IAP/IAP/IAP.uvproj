# Keil uVision project IAP.uvproj, settings and files
target qitas (MCS-51)
  device: CH549 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: BOOT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ADC;.\Compare;.\FlashRom;.\GPIO;.\Public;.\PWM;.\SPI;.\Timer;.\TouchKey;.\UART;.\USB;.\Type_C
  group Boot
    ./: CH549_IAP.C
